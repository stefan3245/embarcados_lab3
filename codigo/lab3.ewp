# IAR project lab3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; lib-board; lib-cmsis; lib-cmsis-os; lib-mcu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lab3.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkAdditionalLibs: G:\Dropbox\Faculdade\9_periodo\sistEmbarcados\labs\3\git\embarcados_lab3\codigo\lib-cmsis-os\rtx\RTX_CM3.a; G:\Dropbox\Faculdade\9_periodo\sistEmbarcados\labs\3\git\embarcados_lab3\codigo\lib-cmsis-os\rtx\RTX_Lib_CM.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group lab3
    lab3/: cbuf.c cbuf.h comunicacao.c comunicacao.h uart_driver.c uart_driver.h
  group lib-cmsis
    lib-cmsis/: cstartup_M.s mcu_regs.h system_LPC17xx.c system_LPC17xx.h
  group lib-cmsis-os
    lib-cmsis-os/: cmsis_os.h
  group lib-cmsis-os/rtx
    lib-cmsis-os/rtx/: RTX_CM_lib.h RTX_Conf_CM.c
  group lib-mcu
    lib-mcu/: lpc17xx_adc.c lpc17xx_adc.h lpc17xx_can.c lpc17xx_can.h lpc17xx_clkpwr.c lpc17xx_clkpwr.h lpc17xx_dac.c lpc17xx_dac.h lpc17xx_emac.c lpc17xx_emac.h lpc17xx_exti.c lpc17xx_exti.h lpc17xx_gpdma.c lpc17xx_gpdma.h lpc17xx_gpio.c lpc17xx_gpio.h lpc17xx_i2c.c lpc17xx_i2c.h lpc17xx_i2s.c lpc17xx_i2s.h lpc17xx_iap.c lpc17xx_iap.h lpc17xx_libcfg_default.c lpc17xx_libcfg_default.h lpc17xx_mcpwm.c lpc17xx_mcpwm.h lpc17xx_nvic.c lpc17xx_nvic.h lpc17xx_pinsel.c lpc17xx_pinsel.h lpc17xx_pwm.c lpc17xx_pwm.h lpc17xx_qei.c lpc17xx_qei.h lpc17xx_rit.c lpc17xx_rit.h lpc17xx_rtc.c lpc17xx_rtc.h lpc17xx_spi.c lpc17xx_spi.h lpc17xx_ssp.c lpc17xx_ssp.h lpc17xx_systick.c lpc17xx_systick.h lpc17xx_timer.c lpc17xx_timer.h lpc17xx_wdt.c lpc17xx_wdt.h lpc_types.h
